options:
  parameters:
    generate_options: qt_gui
    id: gnu_radio_controller
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Local_oscillator
  id: variable
  parameters:
    value: 1.0E9
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 2E9
  states: {}
- name: bandwidth_view
  id: variable
  parameters:
    value: 11E9
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: 11E9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: real
    value: '0'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '800E-9'
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '80E-9'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_selector_1, '1']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_selector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_selector_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_selector_1, '0', qtgui_number_sink_0, '0']
- [blocks_selector_1, '0', qtgui_time_sink_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_selector_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
