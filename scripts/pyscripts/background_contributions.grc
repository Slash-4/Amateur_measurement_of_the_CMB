options:
  parameters:
    generate_options: qt_gui
    id: background_contributions
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Boltzman
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: P_cold
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: P_hot
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_sub_xx_0, '0']
- [blocks_file_source_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_divide_xx_0, '1']

metadata:
  file_format: 1
