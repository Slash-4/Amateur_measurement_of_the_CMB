options:
  parameters:
    author: slash
    generate_options: qt_gui
    id: Rho_factor_measurement
    output_language: python
    title: Rho factor output
  states: {}

blocks:
- name: T_cold
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '77'
  states: {}
- name: T_hot
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '200'
  states: {}
- name: gain_saturation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rho_value_path
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: T_cold
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: T_hot
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rho_value_path
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: T_sys_path
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/gain_saturation
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: Tmp Amb
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Tmp Cold
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: P cold
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Kelvin (K)
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: Power (dB)
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: P hot
  states: {}
- name: note_1
  id: note
  parameters:
    note: i[0] - i[1,2,3,...]
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: G =1/gain_sat * (Phot – Pcold)/(Thot – Tcold)
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: 'Tsystem = (Thot – Tcold(Phot/Pcold))/((Phot/Pcold)-1) '
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: Equation
  states: {}
- name: note_1_2
  id: note
  parameters:
    note: T_sys
  states: {}
- name: note_1_2_0
  id: note
  parameters:
    note: Rho
  states: {}
- name: note_2
  id: note
  parameters:
    note: Inverse of gain_sat
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_sub_xx_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_sub_xx_0_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_divide_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0_1, '0', blocks_divide_xx_0_1, '0']
- [blocks_file_source_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_file_source_0_2, '0', blocks_divide_xx_0_1, '1']
- [blocks_file_source_0_2, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0_1, '1']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_sub_xx_0_1, '0', blocks_divide_xx_0_0, '0']

metadata:
  file_format: 1
