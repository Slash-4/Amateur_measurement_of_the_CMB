options:
  parameters:
    generate_options: hb
    id: calibration_block
    output_language: python
    title: Calibration of T_sys and Rho
  states: {}

blocks:
- name: gain_saturation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: T_cold
  id: parameter
  parameters:
    type: eng_float
    value: '200'
  states: {}
- name: T_hot
  id: parameter
  parameters:
    type: eng_float
    value: '77'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: T_cold
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: T_hot
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/gain_saturation
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Kelvin (K)
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: Power (dB)
  states: {}
- name: note_1
  id: note
  parameters:
    note: i[0] - i[1,2,3,...]
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: G =1/gain_sat * (Phot – Pcold)/(Thot – Tcold)
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: 'Tsystem = (Thot – Tcold(Phot/Pcold))/((Phot/Pcold)-1) '
  states: {}
- name: note_1_2
  id: note
  parameters:
    note: T_sys
  states: {}
- name: note_1_2_0
  id: note
  parameters:
    note: Rho
  states: {}
- name: note_2
  id: note
  parameters:
    note: Inverse of gain_sat
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: T_sys
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: rho
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: P_hot
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: P_cold
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 32k
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_sub_xx_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_sub_xx_0_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_divide_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_divide_xx_0_0, '0', pad_sink_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0_1, '1']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_sub_xx_0_1, '0', blocks_divide_xx_0_0, '0']
- [pad_source_0, '0', blocks_divide_xx_0_1, '0']
- [pad_source_0, '0', blocks_sub_xx_0_0, '0']
- [pad_source_0_0, '0', blocks_divide_xx_0_1, '1']
- [pad_source_0_0, '0', blocks_sub_xx_0_0, '1']

metadata:
  file_format: 1
