options:
  parameters:
    author: slash
    generate_options: hb
    id: untitled
    output_language: python
    title: t_atm_calibration
  states: {}

blocks:
- name: T_cold
  id: parameter
  parameters:
    type: eng_float
    value: '77'
  states: {}
- name: T_hot
  id: parameter
  parameters:
    type: eng_float
    value: '375'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[float],
                  
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Fit for T_atm
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Kelvin (K)
  states: {}
- name: num_runs
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Rho
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: P_hot
    type: float
    vlen: num_runs
  states: {}
- name: pad_source_1_1
  id: pad_source
  parameters:
    label: P_cold
    type: float
    vlen: num_runs
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 32k
  states: {}

connections:
- [pad_source_1, '0', epy_block_0, '0']

metadata:
  file_format: 1
